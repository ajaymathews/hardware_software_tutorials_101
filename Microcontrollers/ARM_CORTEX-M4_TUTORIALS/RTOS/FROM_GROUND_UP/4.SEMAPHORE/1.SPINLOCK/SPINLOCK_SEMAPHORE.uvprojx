# Keil uVision project SPINLOCK_SEMAPHORE.uvprojx, settings and files
target STM32 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SPINLOCK_SEMAPHORE
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group kernal
    ./: kernel.c kernel.h kernel.s
  group user
    ./: main.c
software components: CMSIS:CORE 5.3.0, Device:STM32Cube Framework:Classic 1.7.4, Device:STM32Cube HAL:Common 1.7.4, Device:STM32Cube HAL:Cortex 1.7.4, Device:STM32Cube HAL:DMA 1.7.4, Device:STM32Cube HAL:GPIO 1.7.4, Device:STM32Cube HAL:PWR 1.7.4, Device:STM32Cube HAL:RCC 1.7.4, Device:STM32Cube HAL:TIM 1.7.4, Device:Startup 2.6.2
