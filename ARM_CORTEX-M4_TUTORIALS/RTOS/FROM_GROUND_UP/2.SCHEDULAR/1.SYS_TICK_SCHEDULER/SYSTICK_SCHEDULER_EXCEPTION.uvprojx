# Keil uVision project SYSTICK_SCHEDULER_EXCEPTION.uvprojx, settings and files
target SYSTICK_EXCEPTION (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: SYSTICK_SCHEDULER_EXCEPTION
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group OS_KERNEL
    ./: kernel.c kernel.s kernel.h
  group USER
    ./: main.c
software components: CMSIS:CORE 5.3.0, Device:Startup 2.6.2
